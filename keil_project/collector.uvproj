# Keil uVision project collector.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: collector +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group 源组 1
    ../src/: STARTUP.A51 analyze.c ch438uart1.c interseral.c lower.c Main.c si4432.c si4432spi.c stdlib.c store.c upper.c ch438direct_simulate.c
